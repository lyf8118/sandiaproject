<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TestBoard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer\Timer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


