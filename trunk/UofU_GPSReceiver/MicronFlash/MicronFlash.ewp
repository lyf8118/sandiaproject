# IAR project MicronFlash.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
    ../Main/: UGPS.h
    ../Main/USBCDC/: USBCDC_constructs.c
  group CDC_Stack
    ../Main/USBCDC/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group Common
    ../Main/USBCDC/Common/: hal_UCS.c TLV.c
  group Headers
    ../Main/USBCDC/Common/: device.h hal_UCS.h TLV_descriptors.h types.h
  group HID_Stack
    ../Main/USBCDC/USB_HID_API/: HidReportHandler.c HidReportHandler.h UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB
    ../Main/USBCDC/USB_Common/: defMSP430USB.h descriptors.c descriptors.h dma.c usb.c usb.h usb_eventHandling.c UsbIsr.c UsbIsr.h
