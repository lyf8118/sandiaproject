<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\test\ADCtest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TimerA.ewp</path>
  </project>
  <batchBuild/>
</workspace>


