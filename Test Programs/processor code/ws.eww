<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\mcu\mcu1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\USBCDC_Example1\USBCDC_Example1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


