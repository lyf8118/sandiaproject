# IAR project USBCDC_Example1.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 400
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c USBCDC_constructs.c
  group CDC_Stack
    USB_CDC_API/: UsbCdc.c UsbCdc.h
  group Common
    Common/: hal_UCS.c TLV.c
  group Headers
    Common/: device.h hal_UCS.h TLV_descriptors.h types.h
  group HID_Stack
    USB_HID_API/: HidReportHandler.c HidReportHandler.h UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB
    USB_Common/: defMSP430USB.h descriptors.c descriptors.h dma.c usb.c usb.h usb_eventHandling.c UsbIsr.c UsbIsr.h
